# IAR project LeaderUAV.ewp, settings and files
configuration STM32F4-DISCO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32F407xx; USE_HAL_DRIVER; USE_STM32F4_DISCO
  ICCARM.CCIncludePath2: ..\src; ..\src\drivers; ..\src\drivers\Drivers\CMSIS\Include; ..\src\drivers\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\src\drivers\Drivers\STM32F4xx_HAL_Driver\Inc; ..\src\drivers\Drivers\BSP\STM32F4-Discovery; ..\src\drivers\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ..\src\drivers\Middlewares\ST\STM32_USB_Device_Library\Class\CustomHID\Inc; ..\src\drivers\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\src\app; ..\src\app\user; ..\src\app\bootloader; ..\src\app\aircraft; ..\src\dsp; ..\src\os
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: USBH_HID.bin
  ILINK.IlinkOutputFile: STM32F4_DISCO.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration BootloaderDebug (ARM, debug)
  as the first configuration, except:
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx; USE_HAL_DRIVER; USE_STM32F4_DISCO; BOOTLOADER
  ICCARM.CCIncludePath2: ..\src; ..\src\drivers; ..\src\drivers\Drivers\CMSIS\Include; ..\src\drivers\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\src\drivers\Drivers\STM32F4xx_HAL_Driver\Inc; ..\src\drivers\Drivers\BSP\STM32F4-Discovery; ..\src\drivers\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ..\src\drivers\Middlewares\ST\STM32_USB_Device_Library\Class\CustomHID\Inc; ..\src\drivers\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\src\app; ..\src\app\user; ..\src\app\bootloader; ..\src\app\aircraft; ..\src\app\aircraft\thread; ..\src\dsp; ..\src\os; ..\src\os\ucos\ucos\Ports\ARM-Cortex-M4\Generic\IAR; ..\src\os\ucos\ucos\Source; ..\src\os\ucos\ucos_bsp; ..\src\os\ucos\ucos_config; ..\src\os\ucos\ucos_cpu; ..\src\os\ucos\ucos_cpu\ARM-Cortex-M4\IAR; ..\src\os\ucos\ucos_lib; ..\src\os\ucos\ucos_lib\Ports\ARM-Cortex-M4\IAR
  OBJCOPY.OOCOutputFile: bootloader_debug.bin
  ILINK.IlinkOutputFile: bootloader_debug.out
  ILINK.IlinkIcfFile: bootloader_stm32f407xx_flash.icf
configuration AircraftDebug (ARM, debug)
  as the first configuration, except:
  General.FPU2: 4
  ICCARM.CCDefines: AIRCRAFT; STM32F407xx; USE_HAL_DRIVER; USE_STM32F4_DISCO; __FPU_PRESENT; ARM_MATH_CM4; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING
  ICCARM.CCIncludePath2: ..\src; ..\src\app; ..\src\app\user; ..\src\app\bootloader; ..\src\app\aircraft; ..\src\drivers; ..\src\drivers\accel; ..\src\drivers\baro; ..\src\drivers\magn; ..\src\drivers\gps; ..\src\drivers\gyro; ..\src\drivers\rc; ..\src\dsp; ..\src\os; ..\src\lib\conversion; ..\src\lib\mathlib; ..\src\lib\mathlib\filter; ..\src\lib\mathlib\test; ..\src\lib\conversion; ..\src\protocols; ..\src\modules; ..\src\modules\commander; ..\src\modules\imu; ..\src\modules\uORB; ..\src\modules\uORB\topics; ..\src\platform\Drivers\CMSIS\Include; ..\src\platform\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\src\platform\Drivers\STM32F4xx_HAL_Driver\Inc; ..\src\platform\Drivers\BSP\STM32F4-Discovery; ..\src\platform\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ..\src\platform\Middlewares\ST\STM32_USB_Device_Library\Class\CustomHID\Inc; ..\src\platform\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\src\platform\Middlewares\Third_Party\FreeRTOS\Source\include; ..\src\platform\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\src\platform\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\src\platform\Drivers\CMSIS\Include; ..\src\platform\Drivers\CMSIS\Lib\ARM
  AARM.AUserIncludes: ..\src\app\user; ..\src\platform\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F
  OBJCOPY.OOCOutputFile: aircraft_debug.bin
  ILINK.IlinkOutputFile: aircraft_debug.out
  ILINK.IlinkIcfFile: aircraft_stm32f407xx_flash.icf
  group (top)
    ../src/: leader.cpp leader.h leader_misc.h leader_type.h
  group app
    ../src/app/: leader_system.cpp leader_system.h main.cpp
  group app/aircraft
    ../src/app/aircraft/: aircraft.cpp aircraft.h autopilot.cpp autopilot.h calibration.cpp calibration.h circbuf.cpp circbuf.h heartbeat.cpp heartbeat.h logger.cpp logger.h terminal.cpp terminal.h
  group app/bootloader
    ../src/app/bootloader/: bootloader.cpp bootloader.h iap.cpp iap.h
  group app/user
    ../src/app/user/: demo_main.c demo_main.h ffconf.h FreeRTOSConfig.h startup_stm32f407xx.s stm32f4xx_hal_conf.h stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c usbd_conf.c usbd_conf.h usbd_customhid_if.c usbd_customhid_if.h usbd_desc.c usbd_desc.h
  group drivers
    ../src/drivers/: core.cpp core.h device.cpp device.h dma.cpp dma.h driver_type.h errno.h flash.cpp flash.h gpio.cpp gpio.h i2c.cpp i2c.h motor.cpp motor.h pwm.cpp pwm.h ringbuffer.cpp ringbuffer.h sensorhub.cpp sensorhub.h sensorhub_type.h sensors.h spi.cpp spi.h timer.cpp timer.h uart.cpp uart.h usb_dev.cpp usb_dev.h
  group drivers/accel
    ../src/drivers/accel/: accel.h mpu6000.cpp mpu6000.h
  group drivers/baro
    ../src/drivers/baro/: baro.h ms5611.cpp ms5611.h
  group drivers/gps
    ../src/drivers/gps/: drv_gps.h gps.cpp gps.h
  group drivers/magn
    ../src/drivers/magn/: hmc5883.cpp hmc5883.h magn.h
  group drivers/rc
    ../src/drivers/rc/: sbus.cpp sbus.h
  group lib/conversion
    ../src/lib/conversion/: rotation.cpp rotation.h
  group lib/mathlib
    ../src/lib/mathlib/: limits.cpp limits.h mathlib.h mathtype.h matrix.h quaternion.h vector.h
  group lib/mathlib/filter
    ../src/lib/mathlib/filter/: lowpassfilter2p.cpp lowpassfilter2p.h
  group lib/mathlib/test
    ../src/lib/mathlib/test/: test.cpp test.h
  group modules/commander
    ../src/modules/commander/: calibration_messages.h calibration_routines.cpp calibration_routines.h
  group modules/imu
    ../src/modules/imu/: imu.cpp imu.h
  group modules/uORB/topics
    ../src/modules/uORB/topics/: satellite_info.h vehicle_attitude.h vehicle_gps_position.h
  group os
    ../src/os/: kernel.cpp kernel.h msgque.cpp msgque.h mutex.cpp mutex.h semaphore.cpp semaphore.h thread.cpp thread.h
  group platform/Drivers/BSP
    ../src/platform/Drivers/BSP/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery.h stm32f4_discovery_accelerometer.c stm32f4_discovery_accelerometer.h
  group platform/Drivers/CMSIS/Include
    ../src/platform/Drivers/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
  group platform/Drivers/CMSIS/Lib
    ../src/platform/Drivers/CMSIS/Lib/ARM/: arm_cortexM4b_math.lib arm_cortexM4bf_math.lib arm_cortexM4l_math.lib arm_cortexM4lf_math.lib
  group platform/Drivers/Components
    ../src/platform/Drivers/BSP/Components/lis302dl/: lis302dl.c lis302dl.h
    ../src/platform/Drivers/BSP/Components/lis3dsh/: lis3dsh.c lis3dsh.h
  group platform/Drivers/STM32F4xx_HAL_Driver
    ../src/platform/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../src/platform/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
    ../src/platform/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h
  group platform/Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID
    ../src/platform/Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
    ../src/platform/Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc/: usbd_customhid.h
  group platform/Middlewares/ST/STM32_USB_Device_Library/Class/HID
    ../src/platform/Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
    ../src/platform/Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc/: usbd_hid.h
  group platform/Middlewares/ST/STM32_USB_Device_Library/Core
    ../src/platform/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../src/platform/Middlewares/ST/STM32_USB_Device_Library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
  group platform/Middlewares/Third_Party/FreeRTOS/Source
    ../src/platform/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group platform/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
    ../src/platform/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.h
  group platform/Middlewares/Third_Party/FreeRTOS/Source/include
    ../src/platform/Middlewares/Third_Party/FreeRTOS/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig_template.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group platform/Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F
    ../src/platform/Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group platform/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang
    ../src/platform/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group protocols
    ../src/protocols/: niming.cpp niming.h
